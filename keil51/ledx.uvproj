# Keil uVision project ledx.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ledx +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Key.c Nixie.c Timer0.c Delay.h Key.h Nixie.h Timer0.h UART.c UART.h
